# Keil uVision project xbee.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lab7
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: init_interrupts.c init_interrupts.h init_lib.c init_lib.h init_sw_led.c init_sw_led.h LCD.c LCD.h main.c main.h usart.c usart.h
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
